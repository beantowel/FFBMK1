# Keil uVision project FFBMK1.1.uvproj, settings and files
target FFBMK1.1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: FFBMK1.1
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --C99
  c include: ../Inc;    ../Drivers/STM32F1xx_HAL_Driver/Inc;    ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;    ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;    ../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Inc;    ../Drivers/CMSIS/Include;    ../Drivers/CMSIS/Device/ST/STM32F1xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: usbd_desc.c usbd_conf.c main.c usb_device.c stm32f1xx_hal_msp.c stm32f1xx_it.c usbd_pid.c ffbManager.c pid_definition.h
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_ll_usb.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_pwr.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_gpio.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_tim.c stm32f1xx_hal_adc.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_core.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
